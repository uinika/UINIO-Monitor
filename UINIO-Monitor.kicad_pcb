# Repository uinika/UINIO-Monitor

File README.md:

# UINIO-Monitor 显示屏幕模组

[**UINIO-Monitor**](https://gitee.com/uinika/UINIO-Monitor) 是一款同时拼接了 **0.96 英寸 LCD 显示屏**（`ST7735`，`160×80`）、**0.96 英寸 OLED 显示屏**（`SSD1315`，`128×64`）、**1.3 英寸 LCD 显示屏**（`ST7789`，`240×240`）、**2.4 英寸 LCD 显示屏**（`ST7789`，`240×320`）、**1.69 英寸 LCD 显示屏**（`ST7789`，`240×280`） 的五合一屏幕驱动电路设计。

## 设计概要

1. 采用 **FreeCAD** 绘制了合理并且美观的板框（长度与宽度均小于或等于 `10cmm`）；
2. 分别提供有 4 个 `1mm` 直径螺丝孔，便于安装至其它结构件，快速搭建出产品原型；
3. **LCD** 屏幕的外接引脚**线序**全部保持统一，并且重要的**丝印**信息会同时标注在 PCB 的**顶层**与**底层**；
4. PCB 板载 `0.5mm` 间距的 **FPC** 柔性排线连接器，同时还引出了 `2.54mm` 间距的直插排针，便于通过杜邦线快速搭建实验电路；
5. 由于 **OLED** 屏幕的功耗相对较小，因而采用了 `300mA` 输出的线性稳压芯片 `XC6206P332MR`；而功耗相对较大的 **LCD** 屏幕，则统一采用 `ME6211C33M5G-N` 线性稳压芯片；

## 注意事项

1. 工程的 `CAD` 目录下，保存的是 **FreeCAD** 绘制的 PCB 板框草图文件；
2. 工程的 `3D Models` 文件夹，保存的是 LCD 和 OLED 裸屏的 **3D** 模型 **FreeCAD** 源文件；
3. 工程的 `Reference` 目录下提供了裸屏相关的数据手册以及参考原理图；
4. **0.96 英寸 OLED 显示屏** 同时兼容采用 `SSD1306` 和 `SSD1315` 两款驱动芯片的屏幕；
5. 由于 `XC6206P332MR` 电源正负极反接时，极易导致线性稳压芯片烧毁，所以串联 **SOD-323** 封装的肖特基二极管防止反接；
6. 当使用 **Arduino** 的 **U8g2** 库驱动 **0.96 英寸 OLED 显示屏** 的时候，必须焊接上 `R20` 电阻，而 `R19` 电阻位置可以留空；

## 参考技术文档

[UinIO.com 电子技术实验室](http://uinio.com/) 为 UINIO-Monitor 开源项目提供有如下一系列技术参考资料：

1. [《基于 UINIO-MCU-ESP32 的 Arduino 进阶教程》](http://www.uinio.com/Project/Arduino-ESP32/)
2. [《运用 U8G2 与 TFT_eSPI 玩转 UINIO-Monitor 显示屏》](http://www.uinio.com/Project/UINIO-Monitor/)
3. [《BOM 交互式物料清单与 PCB 布线在线预览》](http://uinio.com/archives/BOM/UINIO-Monitor.html)

## KiCad design UINIO-Monitor.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C9, C17, C18: 1uF; C_0603_1608Metric
C7, C8, C12, C13, C14, C15, C16: 1uF; C_0402_1005Metric
C10: 4.7uF; C_0402_1005Metric
C11: 2.2uF; C_0402_1005Metric
FPC1, FPC2, FPC4, FPC7: FPC-SMD_8P-0.5mm; FPC-SMD_8P-P0.5
FPC3: FPC-SMD_4P-0.5mm; FPC-SMD_4P-P0.5
J1, J2, J4, J7: Conn_01x08_Pin; PinHeader_1x08_P2.54mm_Vertical
J3: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
P1: LCD_Pad_10Pin
P2, P5: LCD_Pad_12Pin
P3: OLED_Pad_30Pin
P4: LCD_Pad_13Pin
R1, R3, R15: 1K; R_0603_1608Metric
R2, R4, R16: 10K; R_0603_1608Metric
R5, R6, R17: 10R; R_0603_1608Metric
R7, R8, R9, R14: 4.7K; R_0402_1005Metric
R10: 910K; R_0402_1005Metric
R11: 10K; R_0402_1005Metric
R12: 1K; R_0402_1005Metric
R13: 10R; R_0402_1005Metric
U1, U2, U4, U5: ME6211; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR
U3: XC6206PxxxMR; SOT-23-3
VT1, VT2, VT3, VT4: S8050; SOT-23-3_L2.9-W1.6-P1.90-LS2.9-BL

Connections:
/3.3V_0.96_OLED: C8.1, P3.6 (VBAT), P3.9 (VDD), P3.14 (RESET), R7.1, R8.1, R14.1, U3.2 (VO)
/3.3V_0.96inch: C14.1, C16.2, P4.10 (VCC), P4.12 (LEDA), R11.1, U4.5 (Vout)
/3.3V_1.33inch: C2.2, C6.2, P2.3 (LEDA), P2.4 (VDD), R4.1, U2.5 (Vout)
/3.3V_1.69inch: C9.2, C18.2, P5.3 (LEDA), P5.4 (VDD), R16.1, U5.5 (Vout)
/3.3V_2.4inch: C1.1, C5.2, P1.8 (VCC), P1.9 (LEDA), R2.2, U1.5 (Vout)
/5V_0.96inch: C15.2, FPC4.8, J4.8, U4.1 (Vin), U4.3 (CE)
/5V_1.33inch: C4.2, FPC1.8, J1.8, U2.1 (Vin), U2.3 (CE)
/5V_1.69inch: C17.2, FPC7.8, J7.8, U5.1 (Vin), U5.3 (CE)
/5V_2.4inch: C3.2, FPC2.8, J2.8, U1.1 (Vin), U1.3 (CE)
/BLK_0.96inch: FPC4.1, J4.1, R12.2
/BLK_1.33inch: FPC1.1, J1.1, R3.2
/BLK_1.69inch: FPC7.1, J7.1, R15.2
/BLK_2.4inch: FPC2.1, J2.1, R1.1
/CS_0.96inch: FPC4.2, J4.2, P4.7 (CS)
/CS_1.33inch: FPC1.2, J1.2, P2.8 (CS)
/CS_1.69inch: FPC7.2, J7.2, P5.8 (CS)
/CS_2.4inch: FPC2.2, J2.2, P1.5 (CS)
/D/C_0.96inch: FPC4.3, J4.3, P4.5 (D/C)
/D/C_1.33inch: FPC1.3, J1.3, P2.7 (D/C)
/D/C_1.69inch: FPC7.3, J7.3, P5.7 (D/C)
/D/C_2.4inch: FPC2.3, J2.3, P1.4 (D/C)
/RESET_0.96inch: FPC4.4, J4.4, P4.6 (RESET)
/RESET_1.33inch: FPC1.4, J1.4, P2.11 (RESET)
/RESET_1.69inch: FPC7.4, J7.4, P5.11 (RESET)
/RESET_2.4inch: FPC2.4, J2.4, P1.2 (RESET)
/SCK_0.96_OLED: FPC3.1, J3.1, P3.18 (D0), R7.2
/SCL_0.96inch: FPC4.5, J4.5, P4.4 (SCL)
/SCL_1.33inch: FPC1.5, J1.5, P2.9 (SCL)
/SCL_1.69inch: FPC7.5, J7.5, P5.9 (SCL)
/SCL_2.4inch: FPC2.5, J2.5, P1.3 (SCL)
/SDA_0.96_OLED: FPC3.2, J3.2, P3.19 (D1), P3.20 (D2), R8.2
/SDA_0.96inch: FPC4.6, J4.6, P4.3 (SDA)
/SDA_1.33inch: FPC1.6, J1.6, P2.10 (SDA)
/SDA_1.69inch: FPC7.6, J7.6, P5.10 (SDA)
/SDA_2.4inch: FPC2.6, J2.6, P1.6 (SDA)
GND: C1.2, C2.1, C3.1, C4.1, C5.1, C6.1, C7.2, C8.2, C9.1, C10.2, C11.2, C14.2, C15.1, C16.1, C17.1, C18.1, FPC1.7, FPC1.9, FPC1.10, FPC2.7, FPC2.9, FPC2.10, FPC3.3, FPC3.5, FPC3.6, FPC4.7, FPC4.9, FPC4.10, FPC7.7, FPC7.9, FPC7.10, J1.7, J2.7, J3.3, J4.7, J7.7, P1.1 (GND), P2.1 (GND), P2.5 (GND), P2.6 (GND), P2.12 (GND), P3.1 (NC), P3.8 (VSS), P3.12 (BS2), P3.13 (CS), P3.15 (D/C), P3.16 (RW), P3.17 (RD), P3.21 (D3), P3.22 (D4), P3.23 (D5), P3.24 (D6), P3.25 (D7), P3.29 (VLSS), P3.30 (NC), P4.8 (GND1), P4.13 (GND2), P5.1 (GND), P5.5 (GND), P5.6 (GND), P5.12 (GND), R9.1, R10.1, U1.2 (Vss), U2.2 (Vss), U3.1 (GND), U4.2 (Vss), U5.2 (Vss), VT1.2 (E), VT2.2 (E), VT3.2 (E), VT4.2 (E)
unnamed: C7.1, FPC3.4, J3.4, U3.3 (VI)
unnamed: P1.10 (LEDK), R6.2
unnamed: P2.2 (LEDK), R5.2
unnamed: P3.10 (BS0), R9.2
unnamed: P3.11 (BS1), R14.2
unnamed: C13.1, P3.5 (C1N)
unnamed: C13.2, P3.4 (C1P)
unnamed: C12.1, P3.3 (C2N)
unnamed: C12.2, P3.2 (C2P)
unnamed: P3.26 (IREF), R10.2
unnamed: C11.1, P3.28 (VCC)
unnamed: C10.1, P3.27 (VCOMH)
unnamed: P4.11 (LEDK), R13.2
unnamed: P5.2 (LEDK), R17.2
unnamed: R1.2, R2.1, VT1.1 (B)
unnamed: R6.1, VT1.3 (C)
unnamed: R3.1, R4.2, VT2.1 (B)
unnamed: R5.1, VT2.3 (C)
unnamed: R11.2, R12.1, VT3.1 (B)
unnamed: R13.1, VT3.3 (C)
unnamed: R15.1, R16.2, VT4.1 (B)
unnamed: R17.1, VT4.3 (C)

Notes on the sheet:
0.96 英寸 SSD1315 OLED 屏幕基板
1.69 英寸 ST7789 LCD 屏幕基板
1.33 英寸 ST7789 LCD 屏幕基板
2.4 英寸 ST7789 LCD 屏幕基板
0.96 英寸 ST7735 LCD 屏幕基板

Board: 2 copper layers, 103.3 x 77.9 mm, 59 parts (0 on the bottom side), 58 nets.

## Commit log

2023-01-12 Initial repository.
2023-01-13 Adding CAD files.
2023-01-14 Finish drawing the board frame.
2023-01-16 Start schematic drawing.
2023-01-16 Redraw the schematic.
2023-01-17 Complete schematic drawing.
2023-01-17 Update footprint.
2023-01-18 Complete component layout.
2023-01-19 Complete PCB routing.
2023-01-20 Finish PCB Layout.
2023-01-20 Drawing some 3D models.
2023-01-20 Complete the opening calibration.
2023-01-20 Release UINIO-Monitor version 1.0.0.
2023-02-08 Release UINIO-Monitor version 2.0.0.
2023-02-13 Update PCB.
2023-02-13 Update documents.
2023-02-14 Update board frame.
2023-02-15 Adjust silk screen position.
2023-02-15 Adding an extension board.
2023-02-15 Prepare UINIO-Monitor version 2.0.0.
2023-02-17 PCB layout update.
2023-02-17 Prepare UINIO-Mointor version 2.0.0.
2023-02-27 Update PCB frame.
2023-03-06 reset PCB board.
2023-03-06 Update PCB board.
2023-03-06 Upgrade to Kicad 7.0.0.
2023-03-08 Prepare UINIO-Monitor version 3.0.0.
2023-03-09 Release UINIO-Monitor version 3.0.0.
2023-07-05 Release UINIO-Monitor version 3.1.0.
2023-07-11 Update README.md.
2023-09-01 Release UINIO-Monitor version 3.2.0.
2024-01-11 Release UINIO-Monitor version 3.2.1.
2024-04-22 Release UINIO-Monitor version 3.2.2.
2024-04-30 Upgrade KiCad to version 8.0.2.
